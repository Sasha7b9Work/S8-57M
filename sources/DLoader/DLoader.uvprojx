# Keil uVision project DLoader.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DLoader57
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F437xx,LOADER,DEBUG
  c include: ..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\src\Hardware\FatFS;.\src\Hardware\HAL;.\src\Hardware\USBH;.\src;..\
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\DLoader.sct
  group libs/FatFS
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group libs/HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
  group libs/USBH
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Hardware
    ./src/Hardware/: Controls.h CPU.h CPU.cpp CPU_FLASH.cpp CPU_It.cpp CPU_Panel.cpp Timer.h Timer.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f437xx.s system_stm32f4xx.c
  group Hardware/FatFS
    ./src/Hardware/FatFS/: ffconf.h
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_EEPROM.cpp HAL_FSMC_PAN_stm.cpp HAL_FSMC_stm.cpp HAL_PIO.cpp HAL_PIO.h stm32f4xx_hal_conf.h
  group Hardware/stm32
    ./src/Hardware/stm32/: stm437.cpp stm437.h Timer4XX.cpp Timer4XX.h
  group Hardware/USBH
    ./src/Hardware/USBH/: usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
  group src
    ./src/: defines.h log.cpp log.h main.cpp
  group Display
    ./src/Display/: AdvancedFont_d.cpp Colors.cpp Colors.h Display.cpp Display.h Painter.h Painter_stm.cpp Primitives.cpp Primitives.h Primitives_stm.cpp
  group Display/Font
    ../common/Display/Font/: Font_d.cpp Font_d.h font8.inc
  group FlashDrive
    ./src/FlashDrive/: FlashDrive.h FlashDrive.cpp
  group Keyboard
    ./src/Keyboard/: BufferButtons.cpp BufferButtons.h Keyboard.cpp Keyboard.h
  group Utils
    ./src/Utils/: Buffer.h Buffer.cpp Math.h Math.cpp String.h String.cpp
  group Communicator
    ../common/Communicator/: Message_.h Communicator_.h Communicator_d.cpp
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: DLoader57
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F437xx,LOADER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\DLoader.sct
